options:
  parameters:
    author: ''
    category: '[GRC Hier Blocks]'
    cmake_opt: ''
    comment: ''
    copyright: ''
    description: ''
    gen_cmake: 'On'
    gen_linking: dynamic
    generate_options: qt_gui
    hier_block_src_path: '.:'
    id: test
    max_nouts: '0'
    output_language: python
    placement: (0,0)
    qt_qss_theme: ''
    realtime_scheduling: ''
    run: 'True'
    run_command: '{python} -u {filename}'
    run_options: prompt
    sizing_mode: fixed
    thread_safe_setters: ''
    title: Not titled yet
    window_size: ''
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [8, 8]
    rotation: 0
    state: enabled

blocks:
- name: samp_rate
  id: variable
  parameters:
    comment: ''
    value: '32000'
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [184, 12]
    rotation: 0
    state: enabled
- name: deepwive_v1_deepwive_v1_source_0
  id: deepwive_v1_deepwive_v1_source
  parameters:
    alias: ''
    comment: ''
    model_fn: '''test_models/key_encoder.trt'''
    snr: '20'
    source_fn: '''test_video/v_CleanAndJerk_g24_c02.avi'''
  states:
    bus_sink: false
    bus_source: false
    bus_structure: null
    coordinate: [186, 193]
    rotation: 0
    state: true
connections: []

metadata:
  file_format: 1
